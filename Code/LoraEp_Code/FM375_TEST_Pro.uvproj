# Keil uVision project FM375_TEST_Pro.uvproj, settings and files
target Target 1 (MCS-251)
  device: Flip80251 Typhoon Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: FM375_TEST +hex
  group Source Group 1
    ./: START251.A51 LoraEp.c main.c trap.c LoraEp.h
