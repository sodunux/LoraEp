# Keil uVision project FM375_TEST_Pro.uvproj, settings and files
target Target 1 (MCS-251)
  device: Flip80251 Typhoon Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: FM375_TEST +hex
  group Source Group 1
    ./: START251.A51 main.c trap.c monitor.asm dma.c FLASH.c fm375_uart.c i2c.c init.c module_uart.c PMU.c RAM.c spi.c TIMER.c u7816.c uart.c DISP.c
